# IAR project Project.ewp, settings and files
configuration STEVAL-IPD005V1_VibAna (ARM)
  General.OGChipSelectEditMenu: STM32F469AI ST STM32F469AI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F469xx; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\Inc; ..\Patch; ..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\Drivers\CMSIS\Include; ..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\Drivers\BSP\STEVAL-IDP005; ..\..\..\..\Middlewares\ST\STM32_MotionSP_Library\Inc; ..\..\..\..\Drivers\BSP\Components\ism330dlc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ..\Binary\STEVAL-IDP005V1_VibrationAnalysis.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f469xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/hts221
    ../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
  group Drivers/BSP/Components/ism330dlc
    ../../../../Drivers/BSP/Components/ism330dlc/: ism330dlc.c ism330dlc_reg.c
  group Drivers/BSP/Components/lps22hb
    ../../../../Drivers/BSP/Components/lps22hb/: lps22hb.c lps22hb_reg.c
  group Drivers/BSP/STEVAL-IDP005V1
    ../../../../Drivers/BSP/STEVAL-IDP005/: idp005.c idp005_flash.c idp005_motion_sensors.c idp005_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/STM32_MotionSP_Library
    ../../../../Middlewares/ST/STM32_MotionSP_Library/Src/: MotionSP.c
  group Vibration Analysis/EWARM
    ./: startup_stm32f469xx.s
  group Vibration Analysis/User
    ../Src/: console.c data_communication_srv.c idp005_bus.c idp005_uart.c main.c MotionSP_Manager.c stm32f4xx_hal_msp.c stm32f4xx_it.c TargetPlatform.c
  group Vibration Analysis/User/Patch
    ../Patch/: ism330dlc_Patch.c
