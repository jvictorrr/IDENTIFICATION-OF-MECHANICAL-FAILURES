# Keil uVision project Project.uvprojx, settings and files
target STEVAL-IPD005V1_VibAna (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F469AIYx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x2004FFFF) IRAM2(0x10000000-0x1000FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: STEVAL-IDP005V1_VibrationAnalysis
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\..\Binary\@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F469xx,ARM_MATH_CM4
  c include: ../Inc;../Patch;../../../../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../../../Drivers/CMSIS/Include;../../../../Drivers/STM32F4xx_HAL_Driver/Inc;../../../../Drivers/BSP/Components/Common;../../../../Drivers/BSP/Components/hts221;../../../../Drivers/BSP/Components/lps22hb;../../../../Drivers/BSP/STEVAL-IDP005;../../../../Middlewares/ST/STM32_MotionSP_Library/Inc;../../../../Drivers/BSP/Components/ism330dlc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f469xx.s
  group Doc
    ../: readme.txt
  group Drivers/BSP/Components/lps22hb
    ../../../../Drivers/BSP/Components/lps22hb/: lps22hb_reg.c lps22hb.c
  group VibrationAnalysis/User
    ../Src/: stm32f4xx_hal_msp.c stm32f4xx_it.c main.c TargetPlatform.c console.c data_communication_srv.c idp005_bus.c idp005_UART.c MotionSP_Manager.c
  group VibrationAnalysis/User/Patch
    ../Patch/: ism330dlc_Patch.c
  group Middlewares/STM32_MotionSP_Library
    ../../../../Middlewares/ST/STM32_MotionSP_Library/Src/: MotionSP.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2s.c stm32f4xx_hal_spi.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_adc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal.c stm32f4xx_hal_tim.c stm32f4xx_hal_adc_ex.c
  group Drivers/BSP/Components/hts221
    ../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components/ism330dlc
    ../../../../Drivers/BSP/Components/ism330dlc/: ism330dlc_reg.c ism330dlc.c
  group Drivers/BSP/STEVAL-IDP005V1
    ../../../../Drivers/BSP/STEVAL-IDP005/: idp005_flash.c idp005.c idp005_motion_sensors.c idp005_motion_sensors_ex.c
software components: CMSIS:CORE 5.1.2, CMSIS:DSP 1.5.2
